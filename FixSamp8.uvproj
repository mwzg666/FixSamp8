# Keil uVision project FixSamp8.uvproj, settings and files
target PileCore (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PileCore +hex
  link misc: REMOVEUNUSED
  group Source
    ./: ISR.asm main.c
    ./Flash/: EepRom.c
    ./Uart/: uart.c
    ./Lcd/: Lcd.c LcdApp.c
    ./ModBus/: ModBus.c FlowMeter.c ModBusDev.c ModBusHost.c
    ./Temperaturn/: Temper.c
